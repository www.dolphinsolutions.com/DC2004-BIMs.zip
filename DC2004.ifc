Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-04-11T09:36:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.20.44 - Exporter 21.1.20.44 - Alternate UI 21.1.20.44
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 11 09:36:00 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\d9497dba-4801-4f31-bff5-91752d7ec49c\2ba181ff-1756-4daf-b780-ae13cad8a709\ifc * Database version: 5507 * Database creation date: Thu Apr 11 09:35:57 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 11 09:35:57 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 11 09:35:57 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Circle Head - Project Datum
Pset_AirSideSystemInformation - Name: Level 0
Pset_ProductRequirements - Name: Level 0; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 0; Structural: no
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowTerminal: DC2004:DC2004, DC2004:DC2004:310907
In: Level 0
Type - Material: Render Material 255-255-255
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 460 mm; Height: 330 mm; Seat Height: 884.958 mm; Width: 349.998 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_94 WC pans; CAWS: "N13/10 WC pans and flushing arrangements; CodePerformance: n/a; Color: Gloss White; Constituents: n/a; Description: Mini Wall Hung Toilet; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Gloss; Form: Wall-mounted; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: High Grade Porcelain; ModelNumber: DC2004; ModelReference: DolphinSolutionsLimited_MiniWallHungToilet; Name: MiniWallHungToilet_DolphinSolutionsLimited; NBSDescription: WC pans; NBSTypeID: n/a; NominalDepth: 460; NominalHeight: 330; NominalWidth: 350; ObjectClassification: 23.45.05.21.11.11; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 330 x 350 x 460 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DC2004; Uniclass2015Code: Pr_40_20_93_94; Uniclass2015Title: WC pans; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DC2004
Type - Pset_ElementShading - Color: Gloss White
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_MiniWallHungToilet; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: MiniWallHungToilet_DolphinSolutionsLimited; Category: Pr_40_20_93_94 WC pans
Type - Pset_QuantityTakeOff - Reference: DC2004:DC2004
Pset_DistributionFlowElementCommon - Reference: DC2004:DC2004; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.508362 m2; Volume: 0.0222632 m3
Identity Data - Mark: 1
Other - Family: DC2004: DC2004; Family and Type: DC2004: DC2004; Type: DC2004: DC2004; Type Id: DC2004: DC2004
Phasing - Phase Created: New Construction
